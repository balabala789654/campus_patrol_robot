# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__FPU_PRESENT,MPL_LOG_NDEBUG=1,EMPL,MPU9250,EMPL_TARGET_STM32F4
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\HARDWARE\LED;..\HARDWARE\TIMER;..\HARDWARE\LCD;..\BSP;..\Math;..\Task;..\Task\CAN_receive;..\Task\chassis_task;..\Task\clamp_shook_task;..\Task\TX2_task;..\Task\detect_task;..\BSP\bizhang_usart;..\BSP\iic;..\Math\User_Lib;..\Math\Smooth_Filter;..\BSP\encoder;..\mpu;..\FreeRTOS;..\mpu\TransformFunctions;..\BSP\motor;..\Task\jiguang_task;..\BSP\ros_to_stm32
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c main.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_fsmc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash_ramfunc.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_wwdg.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c cmsis_os.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group README
    ../: readme.txt
  group BSP
    ../BSP/: gpio.c Time3.c can1.c can2.c pwm.c rc.c remote_control.c Time7.c
    ../BSP/bizhang_usart/: bizhang_usart.c bizhang.c
    ../BSP/iic/: iic.c
    ../BSP/encoder/: encoder.c
    ../BSP/motor/: motor.c
    ../BSP/ros_to_stm32/: ros_to_stm32.c
  group Math
    ../Math/: pid.c kalman.c protocol.c
    ../Math/User_Lib/: user_lib.c
  group Task
    ../Task/: start_task.c
    ../Task/CAN_receive/: CAN_receive.c
    ../Task/chassis_task/: chassis_task.c
    ../Task/detect_task/: detect_task.c
    ../Task/TX2_task/: TX2_task.c
    ../Task/jiguang_task/: jiguang_task.c
  group mpu
    ../mpu/: MPU_TIME_Init.c MPU_SPI_Init.c mpu_delay.c IMUTask.c Filter_Control.c BSP_MPU9250_Init.c BSP_Flash.c accelerometer_calibration.c arm_cortexM4lf_math.lib
